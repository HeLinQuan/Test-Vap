# Keil uVision project HC89F30xC_Touch_Library_Code.uvproj, settings and files
target HC89F30xC_Touch_Library_Code (MCS-51)
  device: HC89F302C HC89F3 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: HC89F30xC_Touch_Library_Code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Application;..\..\User\INC;..\..\Libraries;..\..\Application\Buzzer_Driver;..\..\Application;..\..\Application\DISPLAY;..\..\Application\TM1652;..\..\Application\WDT;..\..\Application\TIMER;..\..\Application\EEPROM_R_W;..\..\Application\AD_WORK;..\..\Application\Fun_Handle;..\..\Application\KEY;..\..\Application\USART;..\..\Application\RS485-Modbus
  group HC51_STARTUP
    ../../User/: STARTUP.A51
  group USER
    ../../User/: Main.c
  group Touch_Lib
    ../../Libraries/HC89F30xC_GeneralKey_Touch_Lib_V3.01/: HC89F30xC_GeneralKey_Touch_Auxiliary.c HC89F30xC_GeneralKey_Touch_Lib_CFG.c HC89F30xC_GeneralKey_Touch_Lib_V3.01.LIB
  group TouchUartDebug_Lib
    ../../Libraries/HC89F30xC_TouchUartDebug_Lib_V2.00/: HC89F30xC_TouchUartDebug_Lib_CFG.c HC89F30xC_TouchUartDebug_Lib_V2.00.LIB
  group Included HC Driver
    ../../User/C/: HC89F30xC_IO_INIT.c HC89F30xC_ISR.c HC89F30xC_PORT_MAP.c HC89F30xC_SYS.c
  group ReadMe
    ../../: ReadMe.txt
  group Buzzer_Driver
    ../../Application/Buzzer_Driver/: Buzzer_Driver.c
  group DISPLAY
    ../../Application/DISPLAY/: display.c
  group TM1652
    ../../Application/TM1652/: TM1652.c
  group WDT
    ../../Application/WDT/: WDT.c
  group TIMER
    ../../Application/TIMER/: TIMER.c
  group EEPROM_R_W
    ../../Application/EEPROM_R_W/: E2PROM_R_W.C
  group AD_WORK
    ../../Application/AD_WORK/: AD_TDS.C
  group Fun_Handle
    ../../Application/Fun_Handle/: Fun_Handle.c
  group KEY
    ../../Application/KEY/: KEY.c
  group USART
    ../../Application/USART/: USART.C
  group REDME
    ./: REDME.txt
  group RS485-Modbus
    ../../Application/RS485-Modbus/: RS485.c
    ./: CRC.c
